# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group USER
    ./: STARTUP.A51 app.c pbdata.c
  group HARDWARE
    ./: timer0.c uart1.c uart2.c UltrasonicDataHandle.c
  group README
    ./: readme.txt
