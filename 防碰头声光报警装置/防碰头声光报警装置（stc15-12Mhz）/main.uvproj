# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F104W STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c timer.c usart.c Ultrasonic.c HC_SR04.c Exti.c
