# Keil uVision project TX-nRF24L01+.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F340 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: TX-nRF24L01+ +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../Source/: nRF24L01.c main.c STARTUP.A51
