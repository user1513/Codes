# Keil uVision project Anti_theftAlarmSystem.uvproj, settings and files
target Project (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Anti_theftAlarmSystem +hex
  c flags: Optimize=8 SizeSpeed=1
  group APP
    ./: app.c
  group HARDWARE
    ./: temp.c timer.c usart.c key.c AMPIRE12864.c ds1302.c
  group CORE
    ./: STARTUP.A51
  group README
    ./: readme.txt
