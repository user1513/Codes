# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\DHT11;..\HARDWARE\TIMER;..\HARDWARE\USART2;..\HARDWARE\USART3;..\HARDWARE\Data_Check;..\HARDWARE\_USART_SEND;..\HARDWARE\BH1750FVI;..\HARDWARE\IIC;..\HARDWARE\GPS;..\HARDWARE\USART1;..\HARDWARE\ADC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DHT11/: DHT11.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/Data_Check/: Data_Check.c
    ../HARDWARE/_USART_SEND/: _usart_send.c
    ../HARDWARE/BH1750FVI/: bh1750fvi.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/USART1/: usart1.c
    ../HARDWARE/ADC/: adc.c
