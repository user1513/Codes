# Keil uVision project GPSClock.uvprojx, settings and files
target GPSClock (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\USART2;..\HARDWARE\GPS;..\HARDWARE\KEY;..\HARDWARE\DHT11;..\HARDWARE\HC595;..\HARDWARE\MP3Play;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\DS3231;..\HARDWARE\TIMER;..\HARDWARE\MYEEPROM
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/HC595/: hc595.c
    ../HARDWARE/MP3Play/: MP3Play.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/DS3231/: ds3231.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MYEEPROM/: myeeprom.c
  group README
    ../Readme/: Readme.txt
