# Keil uVision project WaterQualityUnit.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103RCT6 +hex
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\ADC+DMA;..\HARDWARE\timercallback_func;..\HARDWARE\KEY;..\HARDWARE\USART3;..\GAgent\Gizwits;..\GAgent\Utils;..\HARDWARE\OLED;..\HARDWARE\DHT11;..\HARDWARE\DS1302;..\HARDWARE\JQ_8400;..\HARDWARE\USART2;..\HARDWARE\IIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group DRIVER
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC+DMA/: adc.c
    ../HARDWARE/timercallback_func/: Timer_callback_func.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/DS1302/: ds1302.c
    ../HARDWARE/JQ_8400/: jq_8400.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/IIC/: algorithm.c max30102.c myiic.c
  group GAgent
    ../GAgent/Gizwits/: gizwits_product.c gizwits_protocol.c
    ../GAgent/Utils/: common.c dataPointTools.c ringbuffer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group README
    ./: readme.txt
