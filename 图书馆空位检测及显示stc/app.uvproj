# Keil uVision project app.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: app +hex
  c flags: Optimize=8 SizeSpeed=1
  group USAR
    ./: STARTUP.A51 app.c
  group HARDWARE
    ./: timer.c usart.c seat.c
