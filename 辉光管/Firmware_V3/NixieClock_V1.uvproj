# Keil uVision project NixieClock_V1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: NixieClock_V1 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\App;.\HardwareDrivers;.\STC15;.\App
  link misc: REMOVEUNUSED
  group App
    ./App/: main.c Display.c TimeUpdate.c RTC.c Sound.c Exti.c
  group HardwareDrivers
    ./HardwareDrivers/: HV57708.c SD2405ALPI.c
  group STC15
    ./STC15/: ADC.c delay.c GPIO.c timer.c Soft_I2C.c STARTUP.A51
