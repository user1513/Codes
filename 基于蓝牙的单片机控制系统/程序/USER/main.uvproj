# Keil uVision project main.uvproj, settings and files
target MCU (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\CORE;..\USER;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\USART;..\HARDWARE\demo
  group USER
    ./: main.c
  group CORE
    ../CORE/: STARTUP.A51
  group HARDWORE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/demo/: demo.c
  group README
    ../README/: readme.txt
