# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\test;..\HARDWARE\USART2;..\HARDWARE\TIMER;..\HARDWARE\ModbusCRC16;..\HARDWARE\tool_test;..\HARDWARE\t_List;..\USER;..\APP;..\SerialPortScreen\SerialPortScreenFunc;..\SerialPortScreen\DataParsing
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/ModbusCRC16/: ModbusCRC16.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/tool_test/: tool_test.c
    ../HARDWARE/t_List/: tList.c
  group SerialPortScreen
    ../SerialPortScreen/SerialPortScreenFunc/: SerialPortScreenFunc.c
    ../SerialPortScreen/DataParsing/: DataParsing.c
